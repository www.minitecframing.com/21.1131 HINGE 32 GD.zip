# Autodesk Inventor assembly: 21.1131 HINGE 32 GD
## iProperties
Created: 2007-01
Part Number: 21.1131 HINGE 32 GD
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
